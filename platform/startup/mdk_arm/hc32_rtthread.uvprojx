# Keil uVision project hc32_rtthread.uvprojx, settings and files
target rtthread (6240000::V6.24::.\ARMCLANG6_22)
  device: HC32F460JEUA HDSC
  pack: HDSC.HC32F460.1.0.12
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hc32_rtthread +hex
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: HC32F460,USE_DEVICE_DRIVER_LIB,__DEBUG,__CORE_DEBUG
  c include: ..\..\core;..\..\hal;..\..\..\config;..\..\drivers\inc;..\..\mcu\cmsis;..\..\mcu\common;..\..\..\user\include;..\..\..\libraries\rt-thread\include;..\..\..\libraries\rt-thread\bsp;..\..\..\libraries\rt-thread\include\libc;..\..\..\Arduino
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  group user
    ../../../user/: main.cpp InitBoard.cpp
    ../../../libraries/rt-thread/bsp/: board.c
    ../../../user/source/: nm_message.cpp
  group core
    ../../core/: delay.c system.c sysclock.c
  group platform
    ../../syscalls/: syscalls.c new.cpp
    ../../mcu/common/: system_hc32f460.c
    ./: startup_hc32f460.s
  group CONFIG
    ../../../config/: ddl_config.h mcu_config.h mcu_define.h
  group HAL
    ../../hal/: hal.cpp hal_i2c.cpp hal_led.cpp hal_test.cpp
  group driver
    ../../mcu/common/: hc32_ddl.c
    ../../drivers/src/: hc32f460_adc.c hc32f460_clk.c hc32f460_gpio.c hc32f460_i2c.c hc32f460_icg.c hc32f460_interrupts.c hc32f460_spi.c hc32f460_usart.c hc32f460_utility.c hc32f460_efm.c hc32f460_sram.c hc32f460_pwc.c hc32f460_timera.c hc32f460_exint_nmi_swi.c
  group libraries/rtthread
    ../../../libraries/rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../../../libraries/rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../../libraries/rt-thread/bsp/: rtconfig.h
  group Arduino
    ../../../Arduino/avr/: dtostrf.c
    ../../../Arduino/variants/generic_hc32f460/: variant.cpp
    ../../../Arduino/: abi.cpp Print.cpp Stream.cpp WInterrupts.cpp wiring_analog.cpp wiring_digital.cpp WMath.cpp WString.cpp itoa.c wiring_shift.c yield.c
  group Arduino/core
    ../../../Arduino/drivers/adc/: adc.cpp adc_config.cpp
    ../../../Arduino/drivers/gpio/: addon_gpio.c
    ../../../Arduino/drivers/irqn/: irqn.cpp
    ../../../Arduino/drivers/panic/: ddl_assert.c panic.cpp
    ../../../Arduino/drivers/sysclock/: sysclock_util.cpp
    ../../../Arduino/drivers/timera/: timera_config.cpp
    ../../../Arduino/drivers/usart/: Usart.cpp usart_config.cpp usart_sync.cpp
  group Arduino/libraries
    ../../../Arduino/libraries/Wire/src/: Wire.cpp
